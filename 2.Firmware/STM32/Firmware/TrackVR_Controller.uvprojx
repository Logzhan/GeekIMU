# Keil uVision project TrackVR_Controller.uvprojx, settings and files
target GeekIMUv2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GeekIMUv2 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\cmsis;.\cmsis_boot\startup;.\oculus\inc;.\oculus;.\stm_eeprom;.\oculus;.\usb;.\syscalls;.\stm_usb;.\stm_lib;..\Firmware;.\stm_usb\inc;.\stm_lib\inc;.\usb\inc;.\stm_eeprom\inc;.\MPU9150;.\SYSTEM\sys;.\SYSTEM\usart;.\Driver;.\sensor;.\lcd;.\sensor;.\SYSTEM\delay
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c hw_config.c stm32_it.c
  group LIB
    ./stm_lib/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dma.c
  group CMSIS
    ./cmsis/: core_cm3.c
    ./cmsis_boot/: system_stm32f10x.c
  group STARTUP
    ./cmsis_boot/startup/: startup_stm32f10x_md.s
  group USB
    ./stm_usb/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USBFIG
    ./usb/src/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group DRIVER
    ./Driver/: led.c
    ./driver/: feature_config.c gpio.c spi.c
  group system
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/sys/: sys.c
    ./driver/: stmflash.c
    ./system/delay/: delay.c
  group Sensor
    ./sensor/: senddata.c ahrs.c lis3mdl.c mpu6500.c calibrate.c time.c
software components: CMSIS:CORE 5.4.0
